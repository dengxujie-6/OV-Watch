# Keil uVision project test.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: test +hex
  AfterMake: fromelf --text -a -c --output=test\AAA123.dis  .\test\test.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../USER/HwAccess;../USER/Service/HeartRate;../USER/Task/GUI_Task;../USER/Task/HeartRate_Task;../USER/Task/HardWare_init_task;../USER/Task/Key_Task;../USER/Task/PROM_Test;../USER/Task/Power_Task;../USER/Task/Print_Task;../USER/Task/Sensor_Task;../USER/Task/Watchdog_Task;../USER/PageManagement;../USER/GUI_page;../USER/GUI_page/Home;../USER/GUI_page/Menu;../USER/GUI_page/Common;../USER/GUI_page/Tools;../USER/GUI_page/Status;../USER/GUI_page/Diagnostics;../USER/FONTS;../USER/FreeRTOS_Debug;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/LCD;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/lvgl_minimal_runtime;../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl;../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/include;../Middlewares/Third_Party/lvgl_minimal_runtime/port;..\Middlewares\Third_Party\lvgl_minimal_runtime\lvgl\include\lvgl\draw;..\BSP\Key;..\BSP\Power;..\BSP\IIC;..\BSP\EM7028;..\BSP\Watchdog;..\BSP\PROM;..\BSP\BlueTooth;..\BSP\AHT21;..\BSP\LSM303DLHC;..\BSP\MPU6050
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group BSP
    ../BSP/LCD/: st7789v.c CST816T.c I2CVirtual.c
    ../BSP/Key/: bsp_key.c
    ../BSP/Power/: bsp_power.c
    ../BSP/Watchdog/: bsp_ext_watchdog.c
    ../BSP/IIC/: bsp_iic.c
    ../BSP/PROM/: bsp_prom_iic.c bsp_prom.c
    ../BSP/BlueTooth/: bsp_bluetooth.c
    ../BSP/AHT21/: bsp_aht21.c
    ../BSP/LSM303DLHC/: bsp_lsm303dlhc.c
    ../BSP/MPU6050/: bsp_mpu6050.c
    ../BSP/EM7028/: bsp_em7028.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c rtc.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group GUI_APP
    ../USER/HwAccess/: hwaccess.c low_power.c
    ../USER/Task/GUI_Task/: LVGL_Task.c
    ../USER/Task/HardWare_init_task/: HardWare_Init_Task.c
    ../USER/Task/PROM_Test/: prom_test.c
    ../USER/Task/Key_Task/: Key_task.c
    ../USER/Task/Sensor_Task/: Sensor_Task.c
    ../USER/Task/Power_Task/: Power_Task.c
    ../USER/Task/Print_Task/: Print_Task.c
    ../USER/Task/HeartRate_Task/: HeartRate_Task.c ppg_uart_stream.c
    ../USER/Service/HeartRate/: ppg_signal_processor.c
    ../USER/Task/Watchdog_Task/: Watchdog_Task.c
    ../USER/PageManagement/: page_manager.c
    ../USER/FONTS/: my_font_source_han_20.c my_font_source_han_10.c my_font_source_han_13.c my_font_source_han_18.c my_font_source_han_19.c my_font_source_han_38.c my_icon_fonts.c
    ../USER/Pictures/: img_compass_needle.c ui_img_compass_needle_png.c
    ../USER/GUI_page/Home/: home_page.c
    ../USER/GUI_page/Menu/: menu_page.c
    ../USER/GUI_page/Common/: title_page.c
    ../USER/GUI_page/Tools/: calendar_page.c calculator_page.c stopwatch_page.c animation_page.c compass_page.c heart_rate_page.c test_page.c
    ../USER/GUI_page/Status/: charging_page.c dropdown_menu_page.c
    ../USER/GUI_page/Diagnostics/: debug_overlay.c
    ../USER/FreeRTOS_Debug/: freertos_debug.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/port/: lv_port_indev.c
  group Middlewares/LVGL
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/display/: lv_display.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/snapshot/: lv_snapshot.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/font/imgfont/: lv_imgfont.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/: lv_init.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/others/translation/: lv_translation.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/themes/: lv_theme.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/tick/: lv_tick.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/gif/: lv_gif.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/widgets/win/: lv_win.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/Third_Party/lvgl_minimal_runtime/port/: lv_port_disp.c
software components: CMSIS:CORE 4.3.0
